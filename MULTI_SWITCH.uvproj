# Keil uVision project MULTI_SWITCH.uvproj, settings and files
target 目标 1 (MCS-51)
  device: C8051F506 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: MULTI_SWITCH
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51
    ./scr/: 74HC595.c 74HC595.h com.c com.h main.c main.h init.c init.h _Include.h Delay.c Delay.h Send.c Send.h Sub.c Sub.h Timer.c Timer.h
